Commit message: fix: urdf fix

File: config/mowen_param/mowen.urdf (robot description, URDF)
Before this commit: robot mowen, 3 links, 2 joints
Links:
- removed link laser_link
Joints:
- removed joint base_laser_joint
